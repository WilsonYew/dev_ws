Commit message: edit the urdf

File: src/dd_bot/description/robot_core.xacro (robot description, xacro)
@@ -137,5 +137,5 @@
         <collision>
             <geometry>
-                <sphere radius="0.05"/>
+                <sphere radius="0.09"/>
             </geometry>
         </collision>
